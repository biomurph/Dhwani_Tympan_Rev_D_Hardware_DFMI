# Repository biomurph/Dhwani_Tympan_Rev_D_Hardware_DFMI

File README.md:

D_Tympan_DFMI_1.0 consisits of PCB design files catering to the requirements of Indian PCB Manufacturers. 

The following are the changes done in the PCB design files (.pcb file):  

	1.Four layered board with power/gnd planes as follows:
		Top Cu - GND plane   
		Second layer(In. Cu 1) - None  
		Third layer(In. Cu 2) - 3.3 V power plane  
		Bottom Cu - GND plane  
	2.Details about vias:  
		Through hole vias - 0.6mm/0.4mm  
		Blind vias ( In. Cu 2 - B. Cu) - 0.45mm/ 0.15mm  
	3. Changes in component placement:  
		R20, R23 - Moved from B. Cu to F. Cu layer  
		C14, C20, C21, C22,C34 - Moved from B. Cu to F. Cu layer

## KiCad design D_Tympan_DFMI_1.1.kicad_pcb

Board: 4 copper layers, 38.0 x 74.0 mm, 113 parts (20 on the bottom side), 117 nets.

Parts:
BT1: 4UCON-20519; 4UCON-0217-20519
C1, C3, C5, C7, C10, C14, C16, C18, C28, C29, C42: 0.1uF; C_0402
C2, C8, C12, C13, C23, C24, C25, C26, C27, C32, C33, C37, C39: 2.2uF; C_0402
C4, C6, C11, C15: 10uF; C_0402
C9, C17, C19, C20, C21, C22, C34: 1uF; C_0402
C30, C31: 10nF; C_0402
C35: 4.7uF; C_0402
C40: 15pF; C_0402
C41: 22nF; C_0402
CONN1: 8_PIN_microSD; MOLEX_47571-0001
D1: APHB1608SGNC; ABHB1608S
D2, D3: LED; C_1206
D4, D5: Shottkey; ACDBA340-HF
D6: Led_RGB_CA; CLMVB-FKA-CFHEHLCBB7a363
F1: FUSE; C_1206
IC1: MK66FX1M0VMD18; BGA-144-1mm
IC2: MKL02Z32VFG4; QFN-16-1EP_3x3mm_Pitch0.5mm
IC3: BC127
J1: SJ-3523-SMT-TR
J2: SJ-3524-SMT-TR-PI; SJ-3524-SMT-TR
J3: alt Power Pads
L1, L2: 600R; C_0402
L3: 1K; C_0603
MIC1, MIC2: SPM0687LR5H-1
P1: USB_OTG; 10118193_microUSB
P2, P3, P4, P5: CONN_01X06; Pin_Header_Straight_1x06_Pitch2.54mm
P6: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.00mm
P7: CONN_01X01; NPTH_2.4mm
P8, P9, P10: CONN_01X01; NPTH_3.2mm
R1, R11, R19, R20, R32, R33: 1K; R_0402
R2, R3, R4, R5, R6, R7, R9, R10, R26, R27: 33R; R_0402
R8: 2.2K; R_0402
R12, R13: 0R; C_0603
R14, R17: DNP; C_0603
R15, R16: 2.2K; C_0603
R18, R21, R34, R35, R36: 240R; R_0402
R23: 100K; R_0402
R25: 470R; R_0402
R30, R31: 10K; R_0402
RV1: POT; Pin_Header_Straight_1x03_Pitch2.54mm
SW1: CL-SB-22A
SW2: TACT_SWITCH; PTS810
U1: AP2210K-3.3TRG1; SOT-23-5
U2: TLV320AIC3206IRSBT; UQFN-40-1EP_5x5mm_Pitch0.4mm
U3: 74LVC1G66; SOT-353_SC-70-5
U4: LP5907MFX-1.8; SOT-23-5
U5: MCP73831; SOT-23-5
V_USB: DNP; C_0603
Y1: 32.768kHz; LFXTAL009678
Y2: 16MHz; FA_238_16.0000MB_K3

Connections:
+1V8: C6.1, C7.1, C9.1, C10.1, C22.1, P5.1, U2.29, U2.32, U2.39, U2.40, U4.5
+3V3: C3.2, C4.2, C5.2, C16.2, C18.2, C20.1, C27.1, C29.1, C30.1, C31.1, C32.1, C33.1, CONN1.4, D6.1, F1.2, IC1.E5, IC1.E6, IC1.E7, IC1.E8, IC1.F5, IC1.F8, IC1.G1, IC2.1, IC3.30, IC3.31, IC3.32, IC3.33, L1.2, MIC1.4, MIC2.4, P3.1, R19.1, R20.1, RV1.3, U2.10, U2.30, U3.5, U4.1, U4.3
+BATT: BT1.1, D5.2, J3.1, U5.3
/BCLK: IC1.A11, P4.3, R3.1
/BT_CTS: IC1.M8, IC3.40
/BT_PIO0: IC1.F1, IC3.23
/BT_PIO5: IC1.M4, IC3.25
/BT_RTS: IC1.K4, IC3.43
/BT_RX: IC1.E9, IC3.42
/BT_TX: IC1.E10, IC3.41
/BT_nRESET: IC1.K5, IC3.44
/CLK: CONN1.5, IC1.D1
/CMD: CONN1.3, IC1.E4
/DAT0: CONN1.7, IC1.D2
/DAT1: CONN1.8, IC1.D3
/DAT2: CONN1.1, IC1.E2
/DAT3: CONN1.2, IC1.E3
/DIN: IC1.B11, R5.1
/DIN_1: IC1.B12, P3.3
/DOUT: IC1.D8, R6.1
/DOUT_1: IC1.B7, P3.2
/HPL: R12.1, U2.31
/HPR: R13.1, U2.33
/IN1_L: C24.1, C37.1, U2.17
/IN1_R: C23.1, C39.1, U2.18
/IN2_L: C17.1, U2.19
/IN2_R: C19.1, U2.20
/LED_0: IC3.37, R36.1
/LED_1: IC3.38, R34.1
/LED_2: IC3.39, R35.1
/LOL: C25.1, IC3.21, U2.26
/LOR: C26.1, IC3.19, U2.27
/MCLK: IC1.C8, P4.2, R7.1
/MICBIAS: R15.1, U2.23, U3.1
/MICDET: J2.4, U2.34
/MISO_2: IC1.C2, P2.3
/MOSI_2: IC1.C3, P2.4
/M_BIAS: IC1.A3, U3.4
/M_BIAS_1: IC1.H11, P4.1
/PDM_CLK: P2.2, U2.12
/PDM_DAT: P2.1, U2.15
/POT: C14.1, IC1.K11, RV1.2
/PROG: IC2.10, SW2.1, SW2.2
/PTA0: IC1.J5, IC2.8
/PTA1: IC1.J6, IC2.6
/PTA2: IC1.K6, IC2.9
/PTA3: IC1.K7, IC2.7
/RESET_B: IC1.L12, IC2.4, IC2.13
/SCK_2: IC1.B1, P2.5
/SCL2: IC1.K9, P3.5
/SCL/SS: IC1.G12, R10.1, R20.2
/SDA2: IC1.J9, P3.4
/SDA/MOSI: IC1.G11, R9.1, R19.2
/SS_2: IC1.A1, P2.6
/USB: C15.1, D1.3, L3.1, P1.1
/USB0_D+: IC1.H1, R27.2
/USB0_D-: IC1.H2, R26.2
/VREGEN: IC1.E12, IC3.28, R23.1
/V_USB: C35.1, C40.1, C41.1, D4.2, L3.2, U5.4, V_USB.1, V_USB.2
/WCLK: IC1.A12, P4.4, R4.1
/nRESET: IC1.A8, R2.1
/nRESET_1: IC1.J11, P4.5
Earth: C42.2, P1.6, P1.7, P1.8, P1.9, P1.10, P1.11
GND: BT1.2, BT1.3, BT1.4, C3.1, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C14.2, C15.2, C16.1, C18.1, C20.2, C21.2, C22.2, C27.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C40.2, C41.2, C42.1, CONN1.6, CONN1.9, CONN1.10, CONN1.11, CONN1.12, CONN1.13, D1.2, D2.1, D3.1, IC1.C12, IC1.F6, IC1.F7, IC1.G7, IC1.G8, IC1.H3, IC1.H7, IC1.H8, IC1.K2, IC1.M10, IC2.2, IC2.17, IC3.1, IC3.2, IC3.3, IC3.4, IC3.11, IC3.13, IC3.15, IC3.18, IC3.20, IC3.22, IC3.27, J1.1, J2.1, J3.2, L2.2, MIC1.2, MIC1.3, MIC2.2, MIC2.3, P1.5, P3.6, P4.6, P5.6, P6.3, R8.2, R14.2, R17.2, R23.2, R32.2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
unnamed: C1.1, C28.1, IC1.G6, IC1.H6, L2.1
unnamed: C1.2, IC1.G5, R25.1
unnamed: C2.1, U2.36
unnamed: C2.2, U2.38
unnamed: C8.1, U2.35
unnamed: C11.1, U2.22
unnamed: C12.1, U2.24
unnamed: C12.2, J2.2, R15.2
unnamed: C13.1, U2.25
unnamed: C13.2, J2.3, R16.1
unnamed: C17.2, MIC1.1
unnamed: C19.2, MIC2.1
unnamed: C21.1, D4.1, D5.1, U1.1, U1.3
unnamed: C23.2, P5.2
unnamed: C24.2, P5.3
unnamed: C25.2, P5.4
unnamed: C26.2, P5.5
unnamed: C28.2, IC1.M3
unnamed: C37.2, R30.2, R32.1
unnamed: C39.2, R31.2, R33.1
unnamed: D1.1, R11.1
unnamed: D1.4, R1.1
unnamed: D2.2, R18.2
unnamed: D3.2, R21.2
unnamed: D6.2, R34.2
unnamed: D6.3, R35.2
unnamed: D6.4, R36.2
unnamed: F1.1, SW1.1, SW1.4
unnamed: IC1.A9, R18.1
unnamed: IC1.D7, R21.1
unnamed: IC1.H5, L1.1, R25.2
unnamed: IC1.M6, Y1.1
unnamed: IC1.M7, Y1.2
unnamed: IC1.M11, Y2.1
unnamed: IC1.M12, Y2.3
unnamed: IC3.14, R30.1
unnamed: IC3.16, R31.1
unnamed: J1.2, R12.2, R14.1
unnamed: J1.3, R13.2, R17.1
unnamed: P1.2, R26.1
unnamed: P1.3, R27.1
unnamed: R1.2, R11.2, U5.1
unnamed: R2.2, U2.3
unnamed: R3.2, U2.6
unnamed: R4.2, U2.7
unnamed: R5.2, U2.8
unnamed: R6.2, U2.9
unnamed: R7.2, U2.5
unnamed: R8.1, U5.5
unnamed: R9.2, U2.14
unnamed: R10.2, U2.13
unnamed: R16.2, U3.2
VPP: C34.1, IC1.L6, P6.1, P6.2, SW1.2, SW1.5, U1.5

## Commit log

2020-05-01 DMF changes for HiQ electronics bangalore
    DMF changes for HiQ electronics bangalore
2020-05-06 added file
2020-05-06 New commit
2020-05-06 Updated the gerber files for DFMI
2020-08-10 Added DFMI_1.0
2020-08-10 Changes in DFMI1.0
2020-08-10 Changes in the design
2020-08-10 Update README.md
    Fix formatting
2020-08-13 Added some notes on the PCB board file
    This looks basically OK. I would 'soften' some of the traces where you have almost right angles in them, but that may be more asthetic. Please see the notes I have put on the Eco2.Use layer in the bo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
2020-08-13 final save on the changes
2021-03-04 Add files via upload
    Responses to review comments:
    Updated the annual ring to the Gnd net.
    Extended the zone outline of In.2Cu towards board outline to ensure continuity in the Copper pour.
2021-03-04 Add files via upload
    Responses to review comments:
    1. Updated the annual ring in both the microphones to GND net.
    2. Extended the zone outline of In.2 Cu (3.3 V) towards the board outline to ensure connectivity in the Copper pour.
2021-03-10 testing repo settings
